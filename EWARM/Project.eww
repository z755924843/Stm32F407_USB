<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_cdc_key_led.ewp</path>
  </project>
  <batchBuild />
</workspace>
